# Keil uVision project metronom.uvprojx, settings and files
target Source (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: metronom
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Files
    ./: main.c buttons.c buzzer.c irq.c ledz.c pit.c slcd.c TSI.c dealy.c delay.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
